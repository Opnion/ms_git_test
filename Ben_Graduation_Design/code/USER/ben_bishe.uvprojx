# Keil uVision project ben_bishe.uvprojx, settings and files
target Model (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ben_bishe +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\USER;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLib\inc;..\CORE;..\HARDWARE\OLED;..\HARDWARE\DHT11;..\HARDWARE\SG90;..\HARDWARE\HX711;..\HARDWARE\WaterSensor;..\HARDWARE\HC05;..\HARDWARE\Funtion;..\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/DHT11/: DHT11.c
    ../HARDWARE/HX711/: HX711.c
    ../HARDWARE/WaterSensor/: WaterSensor.c
    ../HARDWARE/SG90/: SG90.c
    ../HARDWARE/HC05/: HC05.c
    ../HARDWARE/Funtion/: function.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
