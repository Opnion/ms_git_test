# Keil uVision project Template.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\HARDWARE\BUZZER;..\HARDWARE\GSM;..\HARDWARE\HC-SR501;..\HARDWARE\KEY;..\HARDWARE\WS2812B;..\HARDWARE\DCMI;..\HARDWARE\LCD;..\HARDWARE\OV2640;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\SRAM;..\HARDWARE\TIMER;..\HARDWARE\W25QXX;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\PICTURE;..\FWLIB\inc;..\SYSTEM\usart;..\APP;..\AUDIOCODEC\wav;..\HARDWARE\24CXX;..\HARDWARE\I2S;..\HARDWARE\IIC;..\HARDWARE\WM8978
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/BUZZER/: BUZZER.c
    ../HARDWARE/HC-SR501/: HC-SR501.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/GSM/: GSM.c
    ../HARDWARE/WS2812B/: WS2812B.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/OV2640/: ov2640.c sccb.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/I2S/: i2s.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/WM8978/: wm8978.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group AUDIOCODEC
    ../AUDIOCODEC/wav/: wavplay.c
  group APP
    ../APP/: audioplay.c recorder.c
